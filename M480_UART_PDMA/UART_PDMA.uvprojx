# Keil uVision project UART_PDMA.uvprojx, settings and files
target UART_PDMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: UART_PDMA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Library\CMSIS\Include;.\Library\StdDriver\inc;.\Library\Device\Nuvoton\M480\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./Library/Device/Nuvoton/M480/Source/: system_M480.c
    ./Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ./: main.c
  group Library
    ./Library/StdDriver/src/: clk.c gpio.c uart.c retarget.c sys.c pdma.c
